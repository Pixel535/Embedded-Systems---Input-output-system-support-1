# Keil uVision project lab3_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lab3_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lab3_2.c
